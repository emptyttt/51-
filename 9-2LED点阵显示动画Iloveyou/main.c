#include <REGX52.H>
#include "Delay.h"
#include "MatrixLED.h"

unsigned char code Animation[]={
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
	0x81,0xFF,0x81,0x00,0x10,0x38,0x7C,0x7E,
	0x3F,0x3F,0x7E,0x7C,0x38,0x10,0x00,0xFF,
	0x00,0x0E,0x11,0x11,0x0E,0x00,0x10,0x0E,
	0x01,0x0E,0x10,0x00,0x0E,0x15,0x15,0x0C,
	0x00,0x00,0x1D,0x05,0x1F,0x00,0x0E,0x11,
	0x11,0x0E,0x00,0x1E,0x01,0x01,0x1E,0x01,
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
	};//放入code不能更改

void main()
{
	unsigned char i,Offset=0,Count=0;
	MatrixLED_Init();
	while(1)
	{
		for(i=0;i<8;i++)
		{
			MatrixLED_ShowColumn(i,Animation[i+Offset]);
		}
		Count++;
		if(Count>10)
		{
			Count=0;
			Offset++;
			if(Offset>56)
			{
				Offset=0;
			}
		}
		
	}
}